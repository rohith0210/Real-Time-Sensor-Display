# Keil uVision project 8051_DHT11_LCD_HC_05_Bluetooth_live_UART_streaming.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 8051_DHT11_LCD_HC_05_Bluetooth_live_UART_streaming +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
